# Keil uVision project dummy.uvproj, settings and files
target Polling (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: dummy
  c flags: Optim=1 wLevel=2
  c define: USE_FULL_ASSERT USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\src;.\src\CMSIS;.\src\uC_OS\BSP;.\src\uC_OS\mC-CPU;.\src\uC_OS\uCOS-Port;.\src\uC_OS\uC-LIB;.\src\uC_OS\uCOS-Src;.\src\SPL\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\src\uC_OS\BSP\STM32_Flash.scat
  link misc: --entry ResetHndlr
  group Startup
    ./src/uC_OS/StartUp/: vectors.s
    ./src/uC_OS/BSP/: init.s
  group Main
    ./src/: app_cfg.h uart.c os_cfg.h main_critical_sections.c main_semaphores.c main_polling.c main_irq_queue.c
  group SPL
    ./src/SPL/src/: misc.c stm32f10x_gpio.c stm32f10x_flash.c stm32f10x_rcc.c stm32f10x_usart.c
    ./src/CMSIS/: stm32f10x_conf.h
  group uc_OS
    ./src/uC_OS/BSP/: bsp.c bsp_int.c bsp_periph.c
    ./src/uC_OS/mC-CPU/: cpu_c.c cpu_a.asm
    ./src/uC_OS/uC-LIB/: lib_mem.c lib_mem_a.asm lib_str.c
    ./src/uC_OS/uCOS-Port/: os_cpu_a.asm os_cpu_c.c os_dbg.c
    ./src/uC_OS/uCOS-Src/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
target Critical_Section (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: dummy
  c flags: Optim=1 wLevel=2
  c define: USE_FULL_ASSERT USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\src\uC_OS\BSP\STM32_Flash.scat
  link misc: --entry ResetHndlr
target Semaphores (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: dummy
  c flags: Optim=1 wLevel=2
  c define: USE_FULL_ASSERT USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\src\uC_OS\BSP\STM32_Flash.scat
  link misc: --entry ResetHndlr
target IRQ_Queue (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: dummy
  c flags: Optim=1 wLevel=2
  c define: USE_FULL_ASSERT USE_STDPERIPH_DRIVER UART_IRQ_TRANSMIT_ENABLE
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\src\uC_OS\BSP\STM32_Flash.scat
  link misc: --entry ResetHndlr
